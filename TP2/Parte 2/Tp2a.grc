options:
  parameters:
    generate_options: qt_gui
    id: Tp1a
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: filtro_crominancia
  id: variable_high_pass_filter_taps
  parameters:
    cutoff_freq: 4e6
    gain: '1.0'
    samp_rate: samp_rate
    width: 1e3
    win: firdes.WIN_RECTANGULAR
  states: {}
- name: filtro_luminancia
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 2.1e6
    gain: '1.0'
    samp_rate: samp_rate
    width: 1e6
    win: firdes.WIN_RECTANGULAR
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '12146841'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: '6'
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/fran/Documents/UCA/4to año/Radiodifusión/WAHD-TV/ve3irr-testing.dat
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: fir_filter_xxx_0_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: filtro_luminancia
    type: fff
  states: {}
- name: fir_filter_xxx_0_0_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: filtro_crominancia
    type: fff
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: views@0:0,0
    name: '"Señal"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: views@0:0,1
    name: '"Luminancia"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: views@0:1,0,1,2
    name: '"Crominancia"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: views@1
    label1: Señal
    label2: Luminancia
    label3: Crominancia
    nconnections: '3'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: views
  id: qtgui_tab_widget
  parameters:
    label0: Separación de señales
    label1: Superpuestas
    num_tabs: '2'
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', blocks_delay_1, '0']
- [blocks_complex_to_mag_0, '0', fir_filter_xxx_0_0, '0']
- [blocks_complex_to_mag_0, '0', fir_filter_xxx_0_0_0, '0']
- [blocks_delay_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_delay_1, '0', qtgui_time_sink_x_1, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', blocks_complex_to_mag_0, '0']
- [fir_filter_xxx_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [fir_filter_xxx_0_0, '0', qtgui_time_sink_x_1, '1']
- [fir_filter_xxx_0_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [fir_filter_xxx_0_0_0, '0', qtgui_time_sink_x_1, '2']

metadata:
  file_format: 1
