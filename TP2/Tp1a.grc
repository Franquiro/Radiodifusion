options:
  parameters:
    generate_options: qt_gui
    id: Tp1a
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: filtro_cromancia
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: 5.5e6
    low_cutoff_freq: 4e6
    samp_rate: samp_rate
    type: band_pass
    width: '500'
    win: firdes.WIN_HAMMING
  states: {}
- name: filtro_luminancia
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 2e6
    gain: '1.0'
    samp_rate: samp_rate
    width: 1e6
    win: firdes.WIN_HAMMING
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 12e6
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/fran/Documents/UCA/4to año/Radiodifusión/WAHD-TV/ve3irr-testing.dat
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: fir_filter_xxx_0_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: filtro_luminancia
    type: fff
  states: {}
- name: fir_filter_xxx_0_0_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: filtro_cromancia
    type: fff
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 0,0,1,2
    name: '"Señal"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 1,0
    name: '"Luminancia"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 1,1
    name: '"Cromancia"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', fir_filter_xxx_0_0, '0']
- [blocks_complex_to_mag_0, '0', fir_filter_xxx_0_0_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', blocks_complex_to_mag_0, '0']
- [fir_filter_xxx_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [fir_filter_xxx_0_0_0, '0', qtgui_time_sink_x_0_0_0, '0']

metadata:
  file_format: 1
