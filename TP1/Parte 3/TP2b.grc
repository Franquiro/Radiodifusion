options:
  parameters:
    author: fran
    generate_options: qt_gui
    id: TP2b
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Vc
  id: variable
  parameters:
    value: '10'
  states: {}
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: 10e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: analog_quadrature_demod_cf_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*fsk_deviation_hz/8.0)
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/fran/Documents/UCA/4to año/Radiodifusión/git/Radiodifusion/TP1/Parte 3/FM.dat
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/Vc
    type: float
  states: {}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    name: '"RMS"'
    type: float
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 0,0,1,2
    name: '"DEMOD"'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '10'
    ymin: '-10'
  states: {}

connections:
- [analog_quadrature_demod_cf_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_rms_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_1_0, '0']
- [blocks_rms_xx_0, '0', qtgui_number_sink_0, '0']
- [blocks_throttle_0, '0', analog_quadrature_demod_cf_0_0, '0']

metadata:
  file_format: 1
