options:
  parameters:
    author: fran
    generate_options: qt_gui
    id: TP2d
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: FiltroBajos
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 4e3
    gain: '1.0'
    samp_rate: samp_rate
    width: '500'
    win: firdes.WIN_HAMMING
  states: {}
- name: FiltroMono
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 15e3
    gain: '1.0'
    samp_rate: samp_rate
    width: 1e3
    win: firdes.WIN_HAMMING
  states: {}
- name: btn_left
  id: variable_qtgui_push_button
  parameters:
    label: L-R
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: btn_right
  id: variable_qtgui_push_button
  parameters:
    label: L+R
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: carrier_max
  id: variable
  parameters:
    value: '19200'
  states: {}
- name: carrier_min
  id: variable
  parameters:
    value: '18800'
  states: {}
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: 075e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 480e3
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*fsk_deviation_hz)
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 19e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/fran/Documents/UCA/4to año/Radiodifusión/git/Radiodifusion/TP1/Parte 3/radio_240k.dat
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: btn_left
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: btn_right
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: FiltroMono
    type: fff
  states: {}
- name: fir_filter_xxx_0_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: FiltroBajos
    type: fff
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    label1: L+R
    label2: L-R
    nconnections: '2'
    type: float
    wintype: firdes.WIN_FLATTOP
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: L+R
    label2: L-R
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '1'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '1'
    taps: ''
    type: fff
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', blocks_multiply_xx_1, '0']
- [analog_quadrature_demod_cf_0, '0', fir_filter_xxx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_add_xx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_multiply_xx_1, '1']
- [blocks_file_source_0, '0', analog_quadrature_demod_cf_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', audio_sink_0, '0']
- [blocks_multiply_xx_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_multiply_xx_1, '0', fir_filter_xxx_0_0, '0']
- [blocks_sub_xx_0, '0', qtgui_freq_sink_x_0_0, '1']
- [blocks_sub_xx_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_sub_xx_0, '0', rational_resampler_xxx_0_0, '0']
- [fir_filter_xxx_0, '0', blocks_add_xx_0, '0']
- [fir_filter_xxx_0, '0', blocks_sub_xx_0, '0']
- [fir_filter_xxx_0_0, '0', blocks_add_xx_0, '1']
- [fir_filter_xxx_0_0, '0', blocks_sub_xx_0, '1']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
