options:
  parameters:
    author: Fran
    generate_options: qt_gui
    id: TP1f
    output_language: python
    title: '"TP1f"'
  states: {}

blocks:
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: 75e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: taps_951
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 80e3
    gain: '1.0'
    samp_rate: samp_rate
    width: 5e3
    win: firdes.WIN_RECTANGULAR
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/fran/Documents/UCA/4to año/Radiodifusión/Prácticas/espectro_2M
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '1'
    samp_rate: samp_rate
    taps: taps_951
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 200e3
    decim: '1'
    samp_rate: samp_rate
    taps: taps_951
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 800e3
    decim: '1'
    samp_rate: samp_rate
    taps: taps_951
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-800e3'
    decim: '1'
    samp_rate: samp_rate
    taps: taps_951
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-200e3'
    decim: '1'
    samp_rate: samp_rate
    taps: taps_951
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 400e3
    decim: '1'
    samp_rate: samp_rate
    taps: taps_951
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_1_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-400e3'
    decim: '1'
    samp_rate: samp_rate
    taps: taps_951
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label1: '103.1'
    label2: '99.1'
    label3: '97.1'
    label4: '95.1'
    label5: '93.1'
    label6: '91.1'
    label7: '87.1'
    label8: '"No Filtrada"'
    name: '"Señal FM recibida por cada emisora"'
    nconnections: '8'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_FLATTOP
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [blocks_throttle_0, '0', freq_xlating_fir_filter_xxx_0_0_0, '0']
- [blocks_throttle_0, '0', freq_xlating_fir_filter_xxx_0_0_0_0, '0']
- [blocks_throttle_0, '0', freq_xlating_fir_filter_xxx_0_0_0_0_0, '0']
- [blocks_throttle_0, '0', freq_xlating_fir_filter_xxx_0_0_0_1, '0']
- [blocks_throttle_0, '0', freq_xlating_fir_filter_xxx_0_0_1, '0']
- [blocks_throttle_0, '0', freq_xlating_fir_filter_xxx_0_0_1_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0_0, '7']
- [freq_xlating_fir_filter_xxx_0_0, '0', qtgui_freq_sink_x_0_0, '3']
- [freq_xlating_fir_filter_xxx_0_0_0, '0', qtgui_freq_sink_x_0_0, '4']
- [freq_xlating_fir_filter_xxx_0_0_0_0, '0', qtgui_freq_sink_x_0_0, '6']
- [freq_xlating_fir_filter_xxx_0_0_0_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0_1, '0', qtgui_freq_sink_x_0_0, '2']
- [freq_xlating_fir_filter_xxx_0_0_1, '0', qtgui_freq_sink_x_0_0, '5']
- [freq_xlating_fir_filter_xxx_0_0_1_0, '0', qtgui_freq_sink_x_0_0, '1']

metadata:
  file_format: 1
