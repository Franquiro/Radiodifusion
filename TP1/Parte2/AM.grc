options:
  parameters:
    author: fran
    generate_options: qt_gui
    id: gnuAM
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: carrier_max_freq
  id: variable
  parameters:
    value: 1005e3
  states: {}
- name: carrier_min_freq
  id: variable
  parameters:
    value: 995e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: taps_BP_PLL
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: carrier_max_freq
    low_cutoff_freq: carrier_min_freq
    samp_rate: samp_rate
    type: band_pass
    width: 10e3
    win: firdes.WIN_HAMMING
  states: {}
- name: taps_LP
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 1e3
    gain: '1.0'
    samp_rate: samp_rate
    width: 2e3
    win: firdes.WIN_HAMMING
  states: {}
- name: analog_pll_refout_cc_0
  id: analog_pll_refout_cc
  parameters:
    max_freq: 2*np.pi*(carrier_max_freq/samp_rate)
    min_freq: 2*np.pi*(carrier_min_freq/samp_rate)
    w: np.pi/200
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/fran/Documents/UCA/4to año/Radiodifusión/git/Radiodifusion/TP1/Parte2/AM.dat
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: fir_filter_xxx_1
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: taps_LP
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '1'
    taps: taps_BP_PLL
    type: ccc
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: views@0
    name: '"Espectro de la Señal"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: views@2
    name: '"Espectro de la Señal"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: views@1
    name: '"Espectro del mensaje"'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: views@1
    label1: msg
    name: '"Mensaje recuperado"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: views@0
    label1: Real
    label2: Imag
    name: '"Señal en tiempo"'
    size: '2048'
    srate: samp_rate
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: views@2
    label1: Real
    label2: Imag
    name: '"Señal en tiempo"'
    size: '4096'
    srate: samp_rate
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}
- name: views
  id: qtgui_tab_widget
  parameters:
    label0: Señal recibida
    label1: Envolvente
    label2: Sincronico
    num_tabs: '3'
  states: {}

connections:
- [analog_pll_refout_cc_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [blocks_complex_to_mag_0, '0', qtgui_freq_sink_x_1, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', fir_filter_xxx_1, '0']
- [blocks_throttle_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [blocks_throttle_0, '0', interp_fir_filter_xxx_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_1, '0']
- [fir_filter_xxx_1, '0', qtgui_freq_sink_x_0_0, '0']
- [fir_filter_xxx_1, '0', qtgui_time_sink_x_1_0, '0']
- [interp_fir_filter_xxx_0, '0', analog_pll_refout_cc_0, '0']

metadata:
  file_format: 1
