options:
  parameters:
    author: fran
    generate_options: qt_gui
    id: TP1d
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: current_window
  id: variable
  parameters:
    value: window.flattop(vector_len)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 32e3
  states: {}
- name: vector_len
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: window_factor
  id: variable
  parameters:
    value: np.sum(pow(np.asarray(current_window),1))/vector_len
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    vlen: vector_len
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/fran/Documents/UCA/4to año/Radiodifusión/Prácticas/espectro_2M
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/(window_factor*np.ones(vector_len)*vector_len)
    type: float
    vlen: vector_len
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '20'
    vlen: vector_len
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vector_len
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: vector_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: current_window
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    vlen: vector_len
    x_start: '0'
    x_step: '1.0'
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_throttle_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_0, '0']

metadata:
  file_format: 1
